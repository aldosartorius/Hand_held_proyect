# Keil uVision project Hand_held.uvprojx, settings and files
target STM32F103C8T6 (6150000::V6.15::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hand_held
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\HAL_GPIO;..\HAL_TIM;..\HAL_LCD;..\HAL_EXTI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./: main.c stm32f1xx_hal_gpio_cfg.h stm32f1xx_hal_gpio_cfg.c stm32f1xx_hal_tim_cfg.c stm32f1xx_hal_tim_cfg.h stm32f1xx_hal_exti_cfg.c stm32f1xx_hal_exti_cfg.h
    ../HAL_GPIO/: stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio.h
    ../HAL_TIM/: stm32f1xx_hal_tim.h stm32f1xx_hal_tim.c
    ../HAL_LCD/: hal_lcd.h hal_lcd.c
    ../HAL_EXTI/: stm32f1xx_hal_exti.h stm32f1xx_hal_exti.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
